# Keil uVision project servo controller.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W408AS STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FF8) CLOCK(35000000) MODP2
  output: servo controller +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\HARDWARE\ADC;..\HARDWARE\EEPROM;..\HARDWARE\MOTOR;..\SYSTEM\sys;..\SYSTEM\TIMER;..\SYSTEM\USART;..\SYSTEM\GPIO;..\SYSTEM\DELAY;..\USER
  group Source Group 1
    ../SYSTEM/sys/: STC15Fxxxx.H config.h
  group USER
    ./: main.c
  group SYSTEM
    ../SYSTEM/USART/: USART1.C
    ../SYSTEM/TIMER/: timer.c
    ../SYSTEM/DELAY/: delay.c
  group HARDWARE
    ../HARDWARE/ADC/: ADC.c
    ../HARDWARE/MOTOR/: motor.c
    ../HARDWARE/EEPROM/: EEPROM.c
